options:
  parameters:
    author: root
    generate_options: qt_gui
    id: LoRaSimLoopback
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: channels_channel_model2_0
  id: channels_channel_model2
  parameters:
    epsilon: '1.0'
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: freq
    noise_voltage: '0.0'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: samp_rate
    sf: '7'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Test Message Input
    type: string
  states: {}

connections:
- [channels_channel_model2_0, '0', lora_rx_0, '0']
- [channels_channel_model_0, '0', lora_rx_0, '0']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', channels_channel_model2_0, '0']
- [lora_tx_0, '0', channels_channel_model_0, '0']
- [qtgui_edit_box_msg_0, msg, lora_tx_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
