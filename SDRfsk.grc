options:
  parameters:
    generate_options: qt_gui
    id: f
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ben/Documents/rx
    type: byte
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: '189'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '10000'
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class pmt_to_string_pass(gr.basic_block):
          def __init__(self):
              gr.basic_block.__init__(self,
                  name="PMT to String Pass Through",
                  in_sig=None,
                  out_sig=None)

              # Register input and output message ports
              self.message_port_register_in(pmt.intern("in"))
              self.message_port_register_out(pmt.intern("out"))
              self.set_msg_handler(pmt.intern("in"), self.handle_pmt_msg)

          def handle_pmt_msg(self, msg):
              # Check if the message is a pair
              if pmt.is_pair(msg):
                  # Extract the payload (cdr)
                  payload = pmt.cdr(msg)
                  # Check if the payload is a byte vector
                  if pmt.is_u8vector(payload):
                      # Extract the byte array from the PMT
                      byte_array = pmt.u8vector_elements(payload)
                      # Convert the byte array to a string
                      decoded_message = ''.join(chr(b) for b in byte_array)
                      # Convert the string back to a PMT
                      new_msg = pmt.cons(pmt.car(msg), pmt.intern(decoded_message))
                      # Pass the new message to the output port
                      self.message_port_pub(pmt.intern("out"), new_msg)

      # To use this block in GNU Radio, you would add it to your flowgraph.
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class custom_message_to_bits(gr.basic_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], file_path="msg.txt"):
              gr.basic_block.__init__(self,
                  name="custom_message_to_bits",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.preamble = np.array(preamble, dtype=np.uint8)
              self.file_path = file_path
              self.chunk_size = 255
              self.set_output_multiple(8 * (len(self.preamble) + self.chunk_size + 1 + 1))  # Output in bits, including CRC
              self.chunks = []
              self.current_chunk_index = 0
              self.message_port_register_in(pmt.intern("crc_status"))
              self.set_msg_handler(pmt.intern("crc_status"), self.handle_crc_status)
              self.message_port_register_out(pmt.intern("out"))
              self.update_message()
              self.transmission_complete = False  # Flag to indicate transmission complete
              self.send_initial_chunk()  # Send the first chunk immediately

          def update_message(self):
              try:
                  with open(self.file_path, "r") as file:
                      message = file.read().strip()
                  message_bytes = np.frombuffer(message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes[i:i + self.chunk_size]) for i in range(0, len(message_bytes), self.chunk_size)]
              except FileNotFoundError:
                  print("Message file not found. Using default message.")
                  default_message = "Default Message"
                  message_bytes = np.frombuffer(default_message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes)]

          def add_crc(self, chunk):
              crc = 0
              for byte in chunk:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              crc_bytes = np.array([crc], dtype=np.uint8)
              return np.concatenate((chunk, crc_bytes))

          def send_initial_chunk(self):
              if self.current_chunk_index < len(self.chunks):
                  chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                  chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                  self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                  #print(f"Sent initial chunk {self.current_chunk_index}.")

          def general_work(self, input_items, output_items):
              if self.transmission_complete:
                  return -1  # Stop the block and flowgraph

              output = output_items[0]

              if self.current_chunk_index < len(self.chunks):
                  chunk = self.chunks[self.current_chunk_index]
                  payload_length = len(chunk) - 1  # Exclude CRC length from payload length
                  header = np.array([payload_length], dtype=np.uint8)
                  packet = np.concatenate((self.preamble, header, chunk))
                  packet_bits = self.byte_to_bits(packet)

                  output[:len(packet_bits)] = packet_bits
                  produced = len(packet_bits)
              else:
                  print("File transmission complete.")
                  self.transmission_complete = True
                  return -1  # Signal to GNU Radio to stop the flowgraph

              self.consume_each(0)  # No input to consume
              return produced

          def byte_to_bits(self, byte_array):
              """Converts a byte array to a bit array."""
              return np.unpackbits(byte_array)

          def handle_crc_status(self, msg):
              if self.transmission_complete:
                  return  # Do nothing if transmission is complete

              status = pmt.symbol_to_string(pmt.car(msg))

              if status == "crc_pass":
                  if self.current_chunk_index < len(self.chunks) - 1:
                      self.current_chunk_index += 1
                      print(f"CRC passed for chunk {self.current_chunk_index}. Moving to the next chunk.")
                      
                      # Send the "chunk_ready" message along with the chunk data
                      chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                      chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                      self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                      
                  else:
                      print("File transmission complete.")
                      self.transmission_complete = True

              elif status == "crc_fail":
                  print(f"Resending chunk {self.current_chunk_index} due to CRC failure.")
    file_path: '''/home/ben/Documents/test2'''
    preamble: '[0xAB, 0xCD, 0xEF, 0xA1, 0x54, 0xEB, 0xBA, 0xDC, 0xFF]'
  states: {}
- name: epy_block_12_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class bits_to_message(gr.sync_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], header_length=1):
              gr.sync_block.__init__(
                  self,
                  name='Bits to Message',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble = np.unpackbits(np.array(preamble, dtype=np.uint8))
              self.header_length = header_length
              self.buffer = np.array([], dtype=np.uint8)
              self.max_buffer_size = 1000000  # Set max buffer size
              self.message_port_register_out(pmt.intern("crc_status"))  # Unified output message port for CRC status
              self.message_port_register_out(pmt.intern("extracted_payload"))  # Message port for extracted payloads
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_message)
              self.current_chunk_index = 0  # Initialize the current chunk index
              self.process_flag = False  # Flag to control processing
              self.file_complete = False  # Flag to indicate if file transmission is complete
              self.final_chunk_processed = False  # Flag to indicate if the final chunk was successfully processed

          def handle_message(self, msg):
              if pmt.is_pair(msg):
                  key = pmt.car(msg)
                  if pmt.eq(key, pmt.intern("demodulated_packet_ready")):
                      self.process_flag = True
                      demodulated_bits = pmt.to_python(pmt.cdr(msg))
                      self.buffer = np.concatenate((self.buffer, demodulated_bits))
                  elif pmt.eq(key, pmt.intern("file_complete")):
                      self.file_complete = True

          def detect_preamble(self, data):
              preamble_length = len(self.preamble)
              for i in range(len(data) - preamble_length + 1):
                  if np.array_equal(data[i:i + preamble_length], self.preamble):
                      return i + preamble_length
              return -1

          def compute_crc(self, data):
              crc = 0
              for byte in data:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              return np.array([crc], dtype=np.uint8)

          def check_crc(self, message, received_crc):
              calculated_crc = self.compute_crc(message)
              return np.array_equal(calculated_crc, received_crc)

          def work(self, input_items, output_items):
              if not self.process_flag or self.final_chunk_processed:
                  return 0  # Do nothing if not ready to process or if the final chunk has been processed

              output_idx = 0  # Initialize output index

              while True:
                  preamble_index = self.detect_preamble(self.buffer)
                  if preamble_index == -1:
                      break

                  header_end = preamble_index + self.header_length * 8
                  if header_end > len(self.buffer):
                      break

                  header = self.buffer[preamble_index:header_end]
                  message_length = np.packbits(header)[0]
                  message_start = header_end
                  message_end = message_start + message_length * 8
                  crc_start = message_end
                  crc_end = crc_start + 8

                  if crc_end > len(self.buffer):
                      break

                  message_bits = self.buffer[message_start:message_end]
                  crc_bits = self.buffer[crc_start:crc_end]

                  message_bytes = np.packbits(message_bits)
                  received_crc = np.packbits(crc_bits)

                  if self.check_crc(message_bytes, received_crc):
                      output_msg = pmt.cons(pmt.intern("crc_pass"), pmt.from_long(self.current_chunk_index))
                      output_items[0][output_idx:output_idx + len(message_bytes)] = message_bytes
                      output_idx += len(message_bytes)
                      self.current_chunk_index += 1

                      # Output the extracted payload for comparison in another block
                      payload_msg = pmt.init_u8vector(len(message_bytes), message_bytes)
                      self.message_port_pub(pmt.intern("extracted_payload"), pmt.cons(pmt.from_long(self.current_chunk_index), payload_msg))

                      # Check if this is the final chunk
                      if self.file_complete and len(self.buffer[crc_end:]) == 0:
                          self.final_chunk_processed = True
                          self.process_flag = False  # Stop processing after the last chunk
                          print("Final chunk processed. Halting further CRC checks.")
                          break

                      # Clear the processed data from the buffer
                      self.buffer = self.buffer[crc_end:]

                  else:
                      #print("CRC failed")
                      output_msg = pmt.cons(pmt.intern("crc_fail"), pmt.from_long(self.current_chunk_index))

                  self.message_port_pub(pmt.intern("crc_status"), output_msg)

              self.consume(0, len(input_items[0]))

              if self.file_complete and len(self.buffer) == 0:  # Check if file transmission is complete and no more chunks are to be processed
                  print("File transmission complete. Halting flowgraph.")
                  return -1  # Signal to GNU Radio to stop the flowgraph

              return output_idx  # Return the number of items produced
    header_length: '1'
    preamble: '[0xAB, 0xCD, 0xEF, 0xA1, 0x54, 0xEB, 0xBA, 0xDC, 0xFF]'
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class custom_message_to_bits(gr.basic_block):
          def __init__(self, preamble=[0xAB, 0xCD, 0xEF], file_path="msg.txt"):
              gr.basic_block.__init__(self,
                  name="custom_message_to_bits",
                  in_sig=None,
                  out_sig=[np.uint8]
              )
              self.preamble = np.array(preamble, dtype=np.uint8)
              self.file_path = file_path
              self.chunk_size = 255
              self.set_output_multiple(8 * (len(self.preamble) + self.chunk_size + 1 + 1))  # Output in bits, including CRC
              self.chunks = []
              self.current_chunk_index = 0
              self.message_port_register_in(pmt.intern("crc_pass"))
              self.message_port_register_in(pmt.intern("crc_fail"))
              self.set_msg_handler(pmt.intern("crc_pass"), self.handle_crc_pass)
              self.set_msg_handler(pmt.intern("crc_fail"), self.handle_crc_fail)
              self.message_port_register_out(pmt.intern("out"))
              self.update_message()
              self.send_initial_chunk()  # Send the first chunk immediately

          def update_message(self):
              try:
                  with open(self.file_path, "r") as file:
                      message = file.read().strip()
                  message_bytes = np.frombuffer(message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes[i:i + self.chunk_size]) for i in range(0, len(message_bytes), self.chunk_size)]
              except FileNotFoundError:
                  print("Message file not found. Using default message.")
                  default_message = "Default Message"
                  message_bytes = np.frombuffer(default_message.encode('utf-8'), dtype=np.uint8)
                  self.chunks = [self.add_crc(message_bytes)]

          def add_crc(self, chunk):
              crc = 0
              for byte in chunk:
                  crc ^= byte
                  for _ in range(8):
                      if crc & 0x80:
                          crc = (crc << 1) ^ 0x07  # Generator polynomial
                      else:
                          crc <<= 1
                  crc &= 0xFF
              crc_bytes = np.array([crc], dtype=np.uint8)
              return np.concatenate((chunk, crc_bytes))

          def byte_to_bits(self, byte_array):
              """Converts a byte array to a bit array."""
              return np.unpackbits(byte_array)

          def send_initial_chunk(self):
              if self.current_chunk_index < len(self.chunks):
                  chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                  chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                  self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                  print(f"Sent initial chunk {self.current_chunk_index}.")

          def general_work(self, input_items, output_items):
              output = output_items[0]

              if self.current_chunk_index < len(self.chunks):
                  chunk = self.chunks[self.current_chunk_index]
                  payload_length = len(chunk) - 1  # Exclude CRC length from payload length
                  header = np.array([payload_length], dtype=np.uint8)
                  packet = np.concatenate((self.preamble, header, chunk))
                  packet_bits = self.byte_to_bits(packet)

                  output[:len(packet_bits)] = packet_bits
                  produced = len(packet_bits)
              else:
                  zeros_length = 8 * (len(self.preamble) + self.chunk_size + 1 + 1)  # Including CRC
                  output[:zeros_length] = np.zeros(zeros_length, dtype=np.uint8)
                  produced = zeros_length

              self.consume_each(0)  # No input to consume
              return produced

          def handle_crc_pass(self, msg):
              if self.current_chunk_index < len(self.chunks) - 1:
                  self.current_chunk_index += 1
                  print(f"CRC passed for chunk {self.current_chunk_index}. Moving to the next chunk.")
                  
                  # Send the "chunk_ready" message along with the chunk data
                  chunk_data = pmt.init_u8vector(len(self.chunks[self.current_chunk_index]), self.chunks[self.current_chunk_index])
                  chunk_ready_msg = pmt.cons(pmt.intern("chunk_ready"), chunk_data)
                  self.message_port_pub(pmt.intern("out"), chunk_ready_msg)
                  
              else:
                  print("File transmission complete.")
                  self.current_chunk_index = len(self.chunks)  # To ensure transmission stops

          def handle_crc_fail(self, msg):
              print(f"Resending chunk {self.current_chunk_index} due to CRC failure.")
    file_path: '''/home/ben/Documents/test2'''
    preamble: '[0xAB, 0xCD, 0xEF, 0xA1, 0x54, 0xEB, 0xBA, 0xDC, 0xFF]'
  states: {state: disabled}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          def __init__(self, samp_rate=1e6, fsk_deviation=500e3):
              gr.sync_block.__init__(
                  self,
                  name='FSK Modulation',
                  in_sig=[np.uint8],
                  out_sig=[np.complex64]
              )
              self.samp_rate = samp_rate
              self.fsk_deviation = fsk_deviation
              self.center_freq = 0
              self.phase_inc0 = 2.0 * np.pi * (self.center_freq - self.fsk_deviation) / self.samp_rate
              self.phase_inc1 = 2.0 * np.pi * (self.center_freq + self.fsk_deviation) / self.samp_rate
              self.phase = 0

              # Register message port to receive chunk_ready messages
              self.message_port_register_in(pmt.intern("in"))
              self.set_msg_handler(pmt.intern("in"), self.handle_message)

              self.chunk_data = None  # Store chunk data when received

          def handle_message(self, msg):
              # Handle the "chunk_ready" message
              if pmt.is_pair(msg):
                  key = pmt.car(msg)
                  if pmt.eq(key, pmt.intern("chunk_ready")):
                      self.chunk_data = pmt.to_python(pmt.cdr(msg))
                      #print(f"Received chunk: {self.chunk_data[:10]}")  # Debug: print the first 10 bits of the chunk

          def work(self, input_items, output_items):
              out = output_items[0]
              in0 = input_items[0]

              # Process the input data
              if len(in0) > 0:  # Ensure there's input data to process
                  #print(f"Modulating data: {in0[:10]}")  # Debug: print the first 10 bits of input data
                  for i in range(len(in0)):
                      if in0[i] == 0:
                          self.phase += self.phase_inc0
                      else:
                          self.phase += self.phase_inc1
                      out[i] = np.exp(1j * self.phase)
                      if self.phase > 2.0 * np.pi:
                          self.phase -= 2.0 * np.pi
              else:
                  print("Received empty input data")  # Debug: indicate when input data is empty

              return len(out)
    fsk_deviation: '250000'
    samp_rate: '1000000.0'
  states: {}
- name: epy_block_2_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\n\nclass fsk_demod(gr.sync_block):\n    def __init__(self, samp_rate=1e6, fsk_deviation=500e3):\n        gr.sync_block.__init__(\n            self,\n            name='FSK Demodulation',\n            in_sig=[np.complex64],\n            out_sig=[np.int8]\n        )\n        self.samp_rate = samp_rate\n        self.fsk_deviation = fsk_deviation\n        self.counter = 0  # Initialize the counter\n\n        # Register a message output port\n        self.message_port_register_out(pmt.intern(\"out\"))\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]\n        out = output_items[0]\n\n        for i in range(1, len(in0)):\n            phase_diff = np.angle(in0[i] * np.conj(in0[i-1]))\n            out[i] = 1 if phase_diff > 0 else 0\n\n        # Send a \"demodulated_packet_ready\" message after processing\n        demodulated_bits = pmt.init_u8vector(len(out), out)\n        demodulated_packet_ready_msg = pmt.cons(pmt.intern(\"demodulated_packet_ready\"), demodulated_bits)\n        self.message_port_pub(pmt.intern(\"out\"), demodulated_packet_ready_msg)\n\n        return len(output_items[0])\n\n"
    fsk_deviation: '250000'
    samp_rate: samp_rate
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '.6'
    decim: '10'
    gain: '1'
    interp: '10'
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: '250000'
    type: interp_fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '.6'
    decim: '10'
    gain: '1'
    ntaps: '100'
    samp_rate: samp_rate
    sym_rate: '250000'
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters: {}
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters: {}
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_message_strobe_0, strobe, blocks_message_debug_0, print]
- [epy_block_0, out, blocks_message_strobe_0, set_msg]
- [epy_block_1, '0', epy_block_2, '0']
- [epy_block_1, out, epy_block_2, in]
- [epy_block_12_0_0, '0', blocks_head_0, '0']
- [epy_block_12_0_0, crc_status, epy_block_1, crc_status]
- [epy_block_12_0_0, extracted_payload, epy_block_0, in]
- [epy_block_2, '0', root_raised_cosine_filter_0, '0']
- [epy_block_2_0, '0', blocks_char_to_float_0, '0']
- [epy_block_2_0, '0', epy_block_12_0_0, '0']
- [epy_block_2_0, out, epy_block_12_0_0, in]
- [root_raised_cosine_filter_0, '0', virtual_sink_0, '0']
- [root_raised_cosine_filter_0_0, '0', epy_block_2_0, '0']
- [virtual_source_0, '0', root_raised_cosine_filter_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
