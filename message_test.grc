options:
  parameters:
    author: root
    generate_options: no_gui
    id: message_test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import time\nimport tkinter as tk\nfrom tkinter import simpledialog\nfrom gnuradio import gr\nimport pmt\n\nclass message_prompt(gr.sync_block):\n    def __init__(self):\n        gr.sync_block.__init__(\n            self,\n            name=\"message_prompt\",\n            in_sig=None,\n            out_sig=None,\n        )\n        self.message_port_register_out(pmt.intern(\"out\"))\n        self.root = tk.Tk()\n        self.root.withdraw()  # Hide the main Tkinter window\n        self.schedule_next_prompt()\n\n    def schedule_next_prompt(self):\n        self.root.after(0, self.prompt_for_message)\n\n    def prompt_for_message(self):\n        payload = simpledialog.askstring(\"Input\", \"Enter payload:\")\n        if payload is not None:\n            message = pmt.intern(payload)\n            for _ in range(3):\n                self.message_port_pub(pmt.intern(\"out\"), message)\n                time.sleep(2)\n        self.schedule_next_prompt()\n\n    def work(self, input_items, output_items):\n        return len(output_items)\n\n"
  states: {}

connections:
- [epy_block_0, out, blocks_message_debug_0, print]

metadata:
  file_format: 1
  grc_version: 3.10.3.0
