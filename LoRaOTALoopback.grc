options:
  parameters:
    author: root
    generate_options: qt_gui
    id: LoRaOTALoopback
    output_language: python
    title: LoRa OTA Loopback
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_debug_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: lora_tx_0
  id: lora_tx
  parameters:
    bw: '125000'
    cr: '1'
    frame_zero_padd: '1280'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    samp_rate: '1000000'
    sf: '7'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"driver=lime,soapy=0"'
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    freq0: 100e6
    freq1: 100e6
    gain0: '10'
    gain1: '10'
    if_gain0: '20'
    if_gain1: '20'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"driver=lime,soapy=0"'
    bb_gain0: '20'
    bb_gain1: '20'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: freq
    freq1: freq
    gain0: '10'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    label: Test Message Input
    type: string
  states: {}

connections:
- [blocks_null_source_0, '0', osmosdr_sink_0, '1']
- [lora_rx_0, out, blocks_message_debug_0, print]
- [lora_tx_0, '0', osmosdr_sink_0, '0']
- [osmosdr_sink_0, async_msgs, blocks_message_debug_0_0, print]
- [osmosdr_source_0, '0', blocks_null_sink_0, '0']
- [osmosdr_source_0, '1', lora_rx_0, '0']
- [qtgui_edit_box_msg_0, msg, lora_tx_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.4.0
