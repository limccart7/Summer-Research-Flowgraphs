options:
  parameters:
    author: root
    generate_options: qt_gui
    id: LoRa_osmo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '915000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: RX_results.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: lora_rx_0
  id: lora_rx
  parameters:
    bw: '125000'
    cr: '1'
    has_crc: 'True'
    impl_head: 'False'
    ldro: '2'
    pay_len: '255'
    print_rx: '[True,True]'
    samp_rate: samp_rate
    sf: '7'
    soft_decoding: 'True'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"driver-lime,soapy=0,nchan=2"'
    bb_gain0: '20'
    bb_gain1: '20'
    bw0: '125000'
    corr1: '0'
    dc_offset_mode1: '0'
    freq0: '915000000'
    freq1: 100e6
    gain0: '20'
    gain1: '10'
    gain_mode0: 'False'
    gain_mode1: 'False'
    if_gain0: '20'
    if_gain1: '20'
    iq_balance_mode1: '0'
    nchan: '2'
    sample_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [lora_rx_0, '0', blocks_file_sink_0, '0']
- [osmosdr_source_0, '0', lora_rx_0, '0']
- [osmosdr_source_0, '1', blocks_null_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
